Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: f3a51646-a1de-4539-a2f9-f600db158adc, NumberOfSaves: 173]
File name: M_Separator_Air_MEPcontent_Spirotech_SpiroVent_BA080F_INT-EN.ifc
Time: 2025-08-05T18:34:37+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
F00 | F00 | 0
F01 | F01 | 3300
F02 | F02 | 6600

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCEANDSINK; PredefinedType: PIPE
Name
Port_2165159_1
Port_2165159_2

# IfcValve: M_Separator_Air_MEPcontent_Spirotech_SpiroVent_BA_INT-EN:BA080F, M_Separator_Air_MEPcontent_Spirotech_SpiroVent_BA_INT-EN:BA080F:2165159
In: F00
Type - Material: Color RGB 168-128-048, Color RAL 1003
Type - Other - Category: Pipe Accessories; Chamfer Radius: 43.8 mm; Connection Diameter: 80 mm; Connector Length: 470 mm; Diameter: 219 mm; Dist B: 3 mm; Dist C: 17 mm; Drain 1: no; Drain 2: yes; Family Name: M_Separator_Air_MEPcontent_Spirotech_SpiroVent_BA_INT-EN; h2: 8.5 mm; h3: 53.8 mm; Handle Offset: 137 mm; Radius: 44.45 mm; Radius A: 100 mm; Radius B: 69 mm; Ring Distance: 125 mm; Rings: no; Rings Offset: 35 mm; Ring Visibility: no; Valve Distance: 235 mm
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Connection Nominal Diameter: 80 mm; Connection Outer Diameter: 88.9 mm; H: 590 mm; h1: 148 mm; L: 370 mm; LF: 470 mm; Use Nominal Diameter: yes
Type - Identity Data - Article Description: Deaerator - Steel- Flange DN80; Article Type: BA080F; Content Supplier URL: www.mepcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Deaerator - Steel- Flange DN80; EMCS Version: 2.0; ETIM Article Class: EC010260; Family Version: 11.14; GLN: 8717811000007; GTIN: 8717811001028; Manufacturer: Spirotech; Manufacturer Art. No.: BA080F; Manufacturer URL: https://www.spirotech.com/8717811001028; MEPcontent Class: SEPARATOR_AIR; Model: BA080F; OmniClass Number: 23.75.50.11.14.14; OmniClass Title: Deaerators; Product Line: Spirotech; Revit Version: 2023; Type Name: BA080F; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Air Vent: Color RGB 168-128-048; Yellow: Color RAL 1003
Type - Mechanical - Capacity: 0 m3; Flow-through Capacity: 0.045 m3/s; Pressure Stage: PN16
Type - Mechanical - Flow - Kv: 0.045 m3/s
Type - Visibility - Flange Connection: yes
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_EnvironmentalImpactIndicators - Reference: BA080F; sets with these values: 2
Other - Family: M_Separator_Air_MEPcontent_Spirotech_SpiroVent_BA_INT-EN; Family and Type: M_Separator_Air_MEPcontent_Spirotech_SpiroVent_BA_INT-EN: BA080F; Type: BA080F; Type Id: 2165123
Constraints - Elevation from Level: 0 mm
Dimensions - Maximum Size: 80 mm; Minimum Size: 80 mm; Volume: 0.0199378 m3
Identity Data - Mark: 11
Mechanical - System Classification: Undefined
Mechanical - Flow - Flow In: 0 m3/s; Pressure Drop: 0 Pa
Phasing - Phase Created: 3. New Construction
Insulation - Insulation Thickness: 0 mm
